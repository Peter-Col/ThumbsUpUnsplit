# Repository Peter-Col/ThumbsUpUnsplit

File README.md:

# ThumbsUpUnsplit
 Multilevel 44 Key Ergonomic Keyboard
/20220219_191523.jpg)
/20220219_191651.jpg)
/20220219_152609.jpg)
/20220219_184854.jpg)
/20220219_184909.jpg)
/20220219_191540.jpg)
/20220219_191637.jpg)

# Firmware

The board was supposed to use Planck rev4 software.
But I made a mistake in schema and mirrored the columns.
To make it work - modify \qmk_firmware\keyboards\planck\config.h, replace the pin definition with this one:

#define MATRIX_COL_PINS { D7, B4, D6, D4, F7, F6, F5, F4, C7, B0, F0, F1 }

## KiCad design ThumbsUpUnsplit.kicad_pcb

Parts:
C1, C2, C6, C7, C10: 0.1uF; C_0805_2012Metric
C3, C8: 1uF; C_0805_2012Metric
C4, C5: 22pF; C_0805_2012Metric
C9: 10uF; C_0805_2012Metric
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44: D_Small; D_SOD-123
F1: Polyfuse; Fuse_1206_3216Metric
J1, J8: Conn_01x18_Male; PinHeader_1x18_P2.54mm_Vertical
J2, J7: Conn_01x18_Female; PinSocket_1x18_P2.54mm_Vertical
J3, J5: Conn_01x04_Female; PinSocket_1x04_P2.54mm_Vertical
J4, J6: Conn_01x04_Male; PinHeader_1x04_P2.54mm_Vertical
J9, J11, J13, J15, J17: Raiser_Female; PinSocket_1x04_P2.54mm_Vertical
J10, J12, J14, J16, J18: Raiser_Male; PinHeader_1x04_P2.54mm_Vertical
MX1, MX2, MX3, MX4, MX5, MX6, MX7, MX8, MX9, MX10, MX11, MX12, MX13, MX14, MX15, MX16, MX17, MX18, MX19, MX20, MX21, MX22, MX23, MX24, MX25, MX26, MX27, MX28, MX29, MX30, MX31, MX32, MX33, MX34, MX35, MX36, MX37, MX38, MX39, MX40, MX41, MX42, MX43, MX44: MX-NoLED; MX-Alps-Choc-KS32-X-1U-NoLED
R1, R2: 22; R_0805_2012Metric
R3, R4: 10k; R_0805_2012Metric
SW1: SW_Push; SKQG-1155865
U1: ATmega32U4-AU; TQFP-44_10x10mm_P0.8mm
USB1: Molex-0548190589
Y1: 16MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm_HandSoldering

Connections:
+5V: C3.1, C9.1, F1.2, U1.2 (UVCC), U1.7 (VBUS), USB1.5 (VBUS)
COL0: J7.1, U1.40 (PF1)
COL1: J7.2, U1.41 (PF0)
COL2: J7.3, U1.8 (PB0)
COL3: J7.4, U1.32 (PC7)
COL4: J6.4, MX27.1 (COL), MX28.1 (COL), MX29.1 (COL), U1.39 (PF4)
COL5: J6.1, MX23.1 (COL), MX24.1 (COL), MX25.1 (COL), U1.38 (PF5)
COL6: J4.4, MX19.1 (COL), MX20.1 (COL), MX21.1 (COL), U1.37 (PF6)
COL7: J4.1, MX15.1 (COL), MX16.1 (COL), MX17.1 (COL), U1.36 (PF7)
COL8: J2.4, U1.25 (PD4)
COL9: J2.3, U1.26 (PD6)
COLA: J2.2, U1.28 (PB4)
COLB: J2.1, U1.27 (PD7)
D+: R2.2, USB1.3 (D+)
D-: R1.2, USB1.4 (D-)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.1, R4.1, SW1.1, U1.5 (UGND), U1.15 (GND), U1.23 (GND), U1.35 (GND), U1.43 (GND), USB1.1 (GND)
unnamed: C4.1, U1.17 (XTAL1), Y1.1
unnamed: C5.1, U1.16 (XTAL2), Y1.3
unnamed: C8.1, U1.6 (UCAP)
unnamed: C10.2, U1.42 (AREF)
unnamed: D1.2 (A), J2.5
unnamed: D2.2 (A), J2.6
unnamed: D3.2 (A), J2.7
unnamed: D4.2 (A), J2.8
unnamed: D5.2 (A), J2.9
unnamed: D6.2 (A), J2.10
unnamed: D7.2 (A), J2.11
unnamed: D8.2 (A), J2.12
unnamed: D9.2 (A), J2.13
unnamed: D10.2 (A), J2.14
unnamed: D11.2 (A), J2.15
unnamed: D12.2 (A), J2.16
unnamed: D13.2 (A), J2.17
unnamed: D14.2 (A), J2.18
unnamed: D15.2 (A), MX15.2 (ROW)
unnamed: D16.2 (A), MX16.2 (ROW)
unnamed: D17.2 (A), MX17.2 (ROW)
unnamed: D18.2 (A), J4.2
unnamed: D19.2 (A), J4.3
unnamed: D20.2 (A), MX19.2 (ROW)
unnamed: D21.2 (A), MX20.2 (ROW)
unnamed: D22.2 (A), MX21.2 (ROW)
unnamed: D23.2 (A), MX23.2 (ROW)
unnamed: D24.2 (A), MX24.2 (ROW)
unnamed: D25.2 (A), MX25.2 (ROW)
unnamed: D26.2 (A), MX27.2 (ROW)
unnamed: D27.2 (A), MX28.2 (ROW)
unnamed: D28.2 (A), MX29.2 (ROW)
unnamed: D29.2 (A), J6.2
unnamed: D30.2 (A), J6.3
unnamed: D31.2 (A), J7.5
unnamed: D32.2 (A), J7.6
unnamed: D33.2 (A), J7.7
unnamed: D34.2 (A), J7.8
unnamed: D35.2 (A), J7.9
unnamed: D36.2 (A), J7.10
unnamed: D37.2 (A), J7.11
unnamed: D38.2 (A), J7.12
unnamed: D39.2 (A), J7.13
unnamed: D40.2 (A), J7.14
unnamed: D41.2 (A), J7.15
unnamed: D42.2 (A), J7.16
unnamed: D43.2 (A), J7.17
unnamed: D44.2 (A), J7.18
unnamed: J1.1, MX1.1 (COL), MX2.1 (COL), MX3.1 (COL)
unnamed: J1.2, MX4.1 (COL), MX5.1 (COL), MX6.1 (COL)
unnamed: J1.3, MX7.1 (COL), MX8.1 (COL), MX9.1 (COL), MX10.1 (COL)
unnamed: J1.4, MX11.1 (COL), MX12.1 (COL), MX13.1 (COL), MX14.1 (COL)
unnamed: J1.5, MX11.2 (ROW)
unnamed: J1.6, MX7.2 (ROW)
unnamed: J1.7, MX4.2 (ROW)
unnamed: J1.8, MX1.2 (ROW)
unnamed: J1.9, MX12.2 (ROW)
unnamed: J1.10, MX8.2 (ROW)
unnamed: J1.11, MX5.2 (ROW)
unnamed: J1.12, MX2.2 (ROW)
unnamed: J1.13, MX13.2 (ROW)
unnamed: J1.14, MX9.2 (ROW)
unnamed: J1.15, MX6.2 (ROW)
unnamed: J1.16, MX3.2 (ROW)
unnamed: J1.17, MX14.2 (ROW)
unnamed: J1.18, MX10.2 (ROW)
unnamed: J3.1, MX18.1 (COL)
unnamed: J3.2, MX18.2 (ROW)
unnamed: J3.3, MX22.2 (ROW)
unnamed: J3.4, MX22.1 (COL)
unnamed: J5.1, MX26.1 (COL)
unnamed: J5.2, MX26.2 (ROW)
unnamed: J5.3, MX30.2 (ROW)
unnamed: J5.4, MX30.1 (COL)
unnamed: J8.1, MX42.1 (COL), MX43.1 (COL), MX44.1 (COL)
unnamed: J8.2, MX39.1 (COL), MX40.1 (COL), MX41.1 (COL)
unnamed: J8.3, MX35.1 (COL), MX36.1 (COL), MX37.1 (COL), MX38.1 (COL)
unnamed: J8.4, MX31.1 (COL), MX32.1 (COL), MX33.1 (COL), MX34.1 (COL)
unnamed: J8.5, MX31.2 (ROW)
unnamed: J8.6, MX35.2 (ROW)
unnamed: J8.7, MX39.2 (ROW)
unnamed: J8.8, MX42.2 (ROW)
unnamed: J8.9, MX32.2 (ROW)
unnamed: J8.10, MX36.2 (ROW)
unnamed: J8.11, MX40.2 (ROW)
unnamed: J8.12, MX43.2 (ROW)
unnamed: J8.13, MX33.2 (ROW)
unnamed: J8.14, MX37.2 (ROW)
unnamed: J8.15, MX41.2 (ROW)
unnamed: J8.16, MX44.2 (ROW)
unnamed: J8.17, MX34.2 (ROW)
unnamed: J8.18, MX38.2 (ROW)
unnamed: R1.1, U1.3 (D-)
unnamed: R2.1, U1.4 (D+)
unnamed: R3.2, SW1.2, U1.13 (~RESET)
unnamed: R4.2, U1.33 (~HWB~/PE2)
ROW0: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D15.1 (K), D20.1 (K), D23.1 (K), D26.1 (K), D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), U1.18 (PD0)
ROW1: D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D16.1 (K), D21.1 (K), D24.1 (K), D27.1 (K), D35.1 (K), D36.1 (K), D37.1 (K), D38.1 (K), U1.22 (PD5)
ROW2: D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D17.1 (K), D22.1 (K), D25.1 (K), D28.1 (K), D39.1 (K), D40.1 (K), D41.1 (K), D42.1 (K), U1.29 (PB5)
ROW3: D13.1 (K), D14.1 (K), D18.1 (K), D19.1 (K), D29.1 (K), D30.1 (K), D43.1 (K), D44.1 (K), U1.30 (PB6)
VCC: C1.1, C2.1, C6.1, C7.1, F1.1, R3.1, U1.14 (VCC), U1.24 (AVCC), U1.34 (VCC), U1.44 (AVCC)

Notes on the sheet:
As in Planck/rev4: #define MATRIX_ROW_PINS { D0, D5, B5, B6 } #define MATRIX_COL_PINS { F1, F0, B0, C7, F4, F5, F6, F7, D4, D6, B4, D7 } #define DIODE_DIRECTION COL2ROW

Board: 2 copper layers, 256.9 x 358.6 mm, 125 parts (72 on the bottom side), 117 nets.

## Commit log

2022-01-27 Project created
2022-01-27 Prepared the project
2022-01-27 Laid out the matrix
2022-01-28 Layed out the switches and edge cuts
2022-01-28 Roughed in the connectors
2022-01-29 Bottom plate routed
2022-01-29 Left side roughed in
2022-01-30 Laid out, ready for the pre-order inspection
2022-02-20 Added pictures
2022-03-17 Added a comment on the firmware.
